# Keil uVision project ZJUDancer.uvprojx, settings and files
target ZJUDancer (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ZJUDancer +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\Library\CMSIS;..\Library\StartUp;..\Library\StdPeriph_Driver\inc;..\USER;..\Library\StdPeriph_Driver\src;..\USER\motor;..\USER\sys;..\USER\usart;..\USER\IMU
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Library/CMSIS/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group StartUp
    ../Library/StartUp/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../Library/StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../USER/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
    ../USER/motor/: motor.c
    ../USER/sys/: sys.c
    ../USER/usart/: usart.c
    ../USER/IMU/: IMU.c
software components: CMSIS:CORE 5.0.1
